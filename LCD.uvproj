# Keil uVision project LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c head.h
  group LCD
    ./: lcd.c lcd.h
  group uart_init
    ./: uart_init.c uart_init.h
  group touch
    ./: touch.h touch.c
  group control
    ./: control.c control.h
  group home
    ./: home.c home.h
  group photo
    ./: photo.c photo.h
  group game
    ./: game.c game.h
